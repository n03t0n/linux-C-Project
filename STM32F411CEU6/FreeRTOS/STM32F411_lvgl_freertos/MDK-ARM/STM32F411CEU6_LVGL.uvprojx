# Keil uVision project STM32F411CEU6_LVGL.uvprojx, settings and files
target STM32F411CEU6_LVGL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F411CEU6_LVGL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --diag_suppress=188,546,68,111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Core/Src/GUI;../Core/Src/TFTLCD;../Core/Src/LVGL;../Core/Src/LVGL/src;../Core/Src/LVGL/examples/porting;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group GUI
    ../Core/Src/GUI/: Digital-7_48.c FHZ17.c FHZ20.c FHZ24.c FHZ30.c FHZ37B.c FHZ40B.c FHZ48.c font.c font.h gui.c gui.h gui_2d_lib.c gui_2d_lib.h gui_interface.c gui_interface.h gui_text_lib.c gui_text_lib.h gui_widget_image.c gui_widget_image.h gui_widget_progbar.c gui_widget_progbar.h gui_widget_text.c gui_widget_text.h inkfree50.c ITC70.c ITC95.c
  group TFT_LCD
    ../Core/Src/TFTLCD/: alientek_log.h tft_font.h tftlcd.c tftlcd.h
  group lvgl
    ../Core/Src/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Core/Src/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Core/Src/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Core/Src/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Core/Src/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Core/Src/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Core/Src/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Core/Src/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Core/Src/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Core/Src/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Core/Src/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Core/Src/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Core/Src/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Core/Src/LVGL/src/extra/: lv_extra.c
    ../Core/Src/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Core/Src/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Core/Src/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Core/Src/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Core/Src/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Core/Src/LVGL/src/extra/widgets/led/: lv_led.c
    ../Core/Src/LVGL/src/extra/widgets/list/: lv_list.c
    ../Core/Src/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Core/Src/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Core/Src/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Core/Src/LVGL/src/extra/widgets/span/: lv_span.c
    ../Core/Src/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Core/Src/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Core/Src/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Core/Src/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Core/Src/LVGL/src/extra/widgets/win/: lv_win.c
    ../Core/Src/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_port
    ../Core/Src/LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
